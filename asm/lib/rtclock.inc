; ------------------  I2C RT CLOCK (DS3231)   ---------------

    IFNDEF __RTCLOCK_INC__
    DEFINE __RTCLOCK_INC__ 1

    STRUCT TIME
SECOND  BYTE
MINUTE  BYTE
HOUR    BYTE
DOW     BYTE
DATE    BYTE
MONTH   BYTE
YEAR    BYTE
    ENDS
    STRUCT A1
SECOND  BYTE
MINUTE  BYTE
HOUR    BYTE
DATE    BYTE
    ENDS
    STRUCT A2
MINUTE  BYTE
HOUR    BYTE
DATE    BYTE
    ENDS
    STRUCT REG
CTRL    BYTE
STATUS  BYTE
AGING   BYTE
;    ALIGN 2
TEMP    WORD
    ENDS
    STRUCT DS3231
TIME    TIME
A1  A1
A2 A2
REG REG
    ENDS

    ENDIF